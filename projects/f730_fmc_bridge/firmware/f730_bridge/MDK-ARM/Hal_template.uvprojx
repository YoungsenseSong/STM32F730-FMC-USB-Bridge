# Keil uVision project Hal_template.uvprojx, settings and files
target Hal_template (6230000::V6.23::ARMCLANG)
  device: STM32F730V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Hal_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F730xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../Bridge/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f730xx.s
  group Application/User/Core
    ../Core/Src/: main.c usart.c gpio.c fmc.c i2c.c iwdg.c tim.c usb_otg.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/BSP
    ../BSP/Src/: bsp.c bsp_led.c bsp_debug.c bsp_time.c bsp_fmc.c bsp_i2c.c bsp_usb.c bsp_fpga_ctrl.c bsp_bridge.c
  group Bridge/Protocol
    ../Bridge/Src/: bridge_protocol.c
  group USB Device
    ../USB_DEVICE/App/: usb_device.c bridge_usb_identity.c usbd_desc.c
    ../USB_DEVICE/Target/: usbd_conf.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
software components: CMSIS:CORE 6.1.0
